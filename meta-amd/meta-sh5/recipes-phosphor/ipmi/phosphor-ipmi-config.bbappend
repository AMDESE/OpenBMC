FILESEXTRAPATHS_prepend_sh5 := "${THISDIR}/${PN}:"
