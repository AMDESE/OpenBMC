SRCREV = "de7dd5ce3133a0201e149b6fdf3d3458fb7f06a5"

S = "${WORKDIR}/git"


