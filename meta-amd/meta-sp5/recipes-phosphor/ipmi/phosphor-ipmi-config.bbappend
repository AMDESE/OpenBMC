FILESEXTRAPATHS_prepend_sp5 := "${THISDIR}/${PN}:"
