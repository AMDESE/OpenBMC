PACKAGECONFIG[flash_scm_fpga] := ""
PACKAGECONFIG[flash_hpm_fpga] := ""
PACKAGECONFIG[flash_vr] := ""
PACKAGECONFIG[flash_retimer] := ""
