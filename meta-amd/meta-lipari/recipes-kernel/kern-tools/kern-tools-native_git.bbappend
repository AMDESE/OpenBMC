
SRCREV = "90598a5fae1172e3f7782a1b02f7b7518efd32c8"
PV = "0.3+git${SRCPV}"

SRC_URI = "git://git.yoctoproject.org/yocto-kernel-tools.git;branch=master"
