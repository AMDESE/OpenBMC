FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRCREV = "a7c723fdd887cf1ac9202de518e9669c7cd09ed6"

SRC_URI += "file://0001-lipari-spl-defconfig.patch \
           "
