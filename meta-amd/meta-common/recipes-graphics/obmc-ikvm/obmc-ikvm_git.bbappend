FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-obmc-ikvm-server-set-to-listen-on-any-interface.patch \
           "

