FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://clear-once.service \
           "
