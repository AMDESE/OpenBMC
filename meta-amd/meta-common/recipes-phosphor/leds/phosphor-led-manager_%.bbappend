FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-led-Replace-upstream-yaml-file-with-AMD-specific-yam.patch \
            "


