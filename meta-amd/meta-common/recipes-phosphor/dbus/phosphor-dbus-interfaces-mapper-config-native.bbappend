PHOSPHOR_MAPPER_SERVICE_append = " com.amd"
PHOSPHOR_MAPPER_INTERFACE_append = " com.amd"
