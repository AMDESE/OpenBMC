FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Fillowing change will disable to create /etc/hostname file
hostname = ""
