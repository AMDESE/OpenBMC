FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-recipes-core-systemd-Modify-default-hostname-setup-logic.patch"
