FILESEXTRAPATHS_prepend_sp6 := "${THISDIR}/${PN}:"
