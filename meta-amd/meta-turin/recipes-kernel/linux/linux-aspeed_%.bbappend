FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"

SRC_URI += "file://turin.cfg \
            file://0001-meta-amd-recipes-kernel-Add-i2c-aliases-for-the-BP.patch \
            "
