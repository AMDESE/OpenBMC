RDEPENDS_${PN}-system += " \
        non-os-binaries \
        "

