FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-u-boot-Add-enable-gpios-to-mount-Lanai-flash.patch"

